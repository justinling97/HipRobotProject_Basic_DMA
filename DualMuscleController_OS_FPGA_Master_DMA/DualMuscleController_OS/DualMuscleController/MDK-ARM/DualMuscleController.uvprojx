# Keil uVision project DualMuscleController.uvprojx, settings and files
target DualMuscleController (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: DualMuscleController +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1U
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../HardwareDriver/MotorControl;../HardwareDriver/ESP32;../HardwareDriver/ATGM336H;../HardwareDriver/PID;../HardwareDriver/MB85RC1M;../HardwareDriver/IIR_FILTER
  asm include: ../Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User
    ../HardwareDriver/MotorControl/: MotorControl.c dynamixel_rd.c
    ../HardwareDriver/ATGM336H/: ATGM336H.c
    ../HardwareDriver/PID/: pid.c
    ../HardwareDriver/MB85RC1M/: MB85RC1M.c
    ../HardwareDriver/IIR_FILTER/: IIR.c
    ../Src/: wit_c_sdk.c wit_IMU.c ControllerIMU.c FPGA_motor_driver.c main.c gpio.c freertos.c adc.c crc.c dma.c fdcan.c i2c.c rtc.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
    ../Inc/: REG.h
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.16.2
